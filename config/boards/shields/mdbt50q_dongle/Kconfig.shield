## config/boards/shields/mdbt50q_dongle/Kconfig.shield
```kconfig
config SHIELD_SOFLE_DONGLE
    def_config_macro = "sofle_dongle"
    bool
    default y
```
